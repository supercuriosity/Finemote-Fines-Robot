# Keil uVision project MC_Board.uvprojx, settings and files
target MC_Board (6190000::V6.19::ARMCLANG)
  device: STM32F446RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MC_Board +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F446xx,__MC_BOARD
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Core/Inc;..;../../../Interface;../../../Services;../../../Devices;../../../Components;../../../Devices/Controllers;../../../Devices/Motors;../../../Algorithms/Communication;../../../Algorithms;../../../Services/Bus;../../../Services/MultiMedia;../../../Services/FineWarden
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c i2c.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP
    ../: MC_Board.cpp
  group Interface
    ../../../Interface/: Interface.cpp
  group Devices/Controllers
    ../../../Devices/Controllers/: DJI_DT7.cpp RadioMaster_Zorro.cpp RemoteControl.cpp
  group Devices/Motors
    ../../../Devices/: DeviceBase.cpp
    ../../../Devices/Motors/: MotorBase.cpp Motor4010.cpp Motor4315.cpp
    ../../../Components/: Chassis.cpp
  group Algorithm/Control
    ../../../Algorithms/Control/: PID.cpp
    ../../../Algorithms/: Matix.cpp
  group Algorithm/Communication
    ../../../Algorithms/Communication/: Verify.cpp Verify.h
  group Services/Bus
    ../../../Services/Bus/: CAN_Base.cpp UART_Base.cpp UARTBaseLite.cpp
  group Services/MultiMedia
    ../../../Services/MultiMedia/: BeepMusic.cpp
  group Services/FineWarden
    ../../../Services/FineWarden/: FZMotion.cpp
software components: CMSIS:CORE 5.4.0
