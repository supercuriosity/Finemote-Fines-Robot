# Keil uVision project Robomaster_C.uvprojx, settings and files
target Robomaster_C (6120000::V6.12::.\ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Robomaster_C +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,__ROBOMASTER_C
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../../Interface;..;../../../Services;../../../Devices;../../../Algorithms/Control;../../../Algorithms;../../../Components/Examples;../../../Components;..\..\..\Services\MultiMedia;..\..\..\Components;..\..\..\Devices\Motors;..\..\..\Devices\Controllers;..\..\..\Algorithms\Communication;..\..\..\Services\Matrix;..\..\..\Services\FineWarden;..\..\..\Services\Bus
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c i2c.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../: Robomaster.cpp
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Interface
    ../../../Interface/: Interface.cpp
  group Services
    ../../../Services/MultiMedia/: BeepMusic.cpp
    ../../../Services/Bus/: I2C_Base.cpp CAN_Base.cpp UART_Base.cpp
  group Devices
    ../../../Devices/: DeviceBase.cpp
    ../../../Devices/Motors/: MotorBase.cpp
    ../../../Services/Bus/: bsp_spi.cpp
  group Algorithms
    ../../../Algorithms/: Matix.cpp MahonyAHRS.cpp
    ../../../Algorithms/Control/: PID.cpp
  group Devices/Controllers
    ../../../Devices/Controllers/: DJI_DT7.cpp RadioMaster_Zorro.cpp RemoteControl.cpp
  group Communication
    ../../../Algorithms/Communication/: Verify.cpp Verify.h
  group Components
    ../../../Components/: Chassis.cpp Chassis.h
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0
